TARGET_CFLAGS:remove = "-Werror=format-security"
CFLAGS:remove = "-Werror=format-security"
